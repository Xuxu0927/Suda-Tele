# Keil uVision project eins.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: eins +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c tou.h onewire.c onewire.h
