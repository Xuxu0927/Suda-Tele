# Keil uVision project rili.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: rili +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: main.c DS1302.h LCD1602.h LED.h DS1302.c LCD1602.c LED.c
